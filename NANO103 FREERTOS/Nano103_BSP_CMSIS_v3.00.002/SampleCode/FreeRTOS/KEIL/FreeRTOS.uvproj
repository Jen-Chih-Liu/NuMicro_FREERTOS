# Keil uVision project FreeRTOS.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: NANO103SD3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FreeRTOS
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\Nano103\Include;..\..\..\Library\StdDriver\inc;..\..\..\FreeRTOSv10.0.1\FreeRTOS\Source\include;..\..\..\FreeRTOSv10.0.1\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\FreeRTOS
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano103.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../../../Library/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group User
    ../: main.c
  group Libraries
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group FreeRTOS
    ../../../FreeRTOSv10.0.1/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../FreeRTOSv10.0.1/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../FreeRTOSv10.0.1/FreeRTOS/Source/portable/MemMang/: heap_2.c
