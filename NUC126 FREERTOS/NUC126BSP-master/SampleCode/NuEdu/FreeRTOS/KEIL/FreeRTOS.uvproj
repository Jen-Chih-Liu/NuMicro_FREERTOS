# Keil uVision project FreeRTOS.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: NUC126VG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FreeRTOS
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC126\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\..\..\..\Library\NuEdu\emWin\tslib;..\..\..\..\Library\NuEdu\emWin\lcm;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\..\..\ThirdParty\FreeRTOS;..\..\FreeRTOS
  asm define: Stack_Size=0x800
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC126.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC126/Source/: system_NUC126.c
    ../../../../Library/Device/Nuvoton/NUC126/Source/ARM/: startup_NUC126.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c sys.c timer.c uart.c fmc.c adc.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
target emWin_GUIDemo_ST7735 (ARM-ADS)
  device: NUC126VG4AE Nuvoton
  cpu: as above
  output: emWin_GUIDemo_ST7735
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __DEMO_160x128__
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC126\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\..\..\..\Library\NuEdu\emWin\tslib;..\..\..\..\Library\NuEdu\emWin\lcm
  asm define: Stack_Size=0x800
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: as above
