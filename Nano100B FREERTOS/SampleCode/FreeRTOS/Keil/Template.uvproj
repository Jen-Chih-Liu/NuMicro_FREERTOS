# Keil uVision project Template.uvproj, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: FreeRTOS
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\Nano100Series\Include;..\..\..\Library\StdDriver\inc;..\..\..\FreeRTOSv10.0.1\FreeRTOS\Source\include;..\..\..\FreeRTOSv10.0.1\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\FreeRTOS
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c clk.c
  group User
    ../: main.c
  group FreeRTOS
    ../../../FreeRTOSv10.0.1/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../FreeRTOSv10.0.1/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../FreeRTOSv10.0.1/FreeRTOS/Source/portable/MemMang/: heap_2.c
